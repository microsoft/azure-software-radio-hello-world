options:
  parameters:
    generate_options: qt_gui
    id: visualize_fm
    output_language: python
    title: Visualize FM Band
  states: {}

blocks:
- name: azure_software_radio_blob_source_0
  id: azure_software_radio_blob_source
  parameters:
    authentication_method: connection_string
    blob_name: fm_wide_20MHz_short.iq
    connection_str: DefaultEndpointsProtocol=https;AccountName=marcpubliciqblobssa;AccountKey=+MGGfNpP6Ht+6nY7gPbwO54ZOIAN19SNvqhlbsrgl900Hb1d3aELZUv3Y48BQSv01fht+WYMcYjwIJ5VSrHKkQ==;EndpointSuffix=core.windows.net
    container_name: public-iq-blobs
    queue_size: '4'
    retry_total: '10'
    type: fc32
    url: ''
    vlen: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 0.1e6
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 20e6
    fc: 100e6
    fftsize: '1024'
    type: complex
    ymax: '-20'
    ymin: '-80'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 20e6
    fc: 100e6
    fftsize: '1024'
    int_max: '-20'
    int_min: '-60'
    type: complex
  states: {}

connections:
- [azure_software_radio_blob_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
